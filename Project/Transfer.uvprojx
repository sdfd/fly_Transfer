# Keil uVision project Transfer.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Transfer +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --C99
  c include: ..\CMSIS;..\Lib\inc;..\User;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ../CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group User
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group BSP
    ../BSP/: Usart1.c NVIC.c SPI.c NRF24L01.c LED.c DMA.c I2C.c MPU6050.c
  group Lib
    ../Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_i2c.c
